## drivers/gpu/arm/Kconfig
```kconfig
config MALI_DEVICE
	bool "mali device"
	help

if ARCH_HI6XXX
source "drivers/gpu/arm/mali4_64/Kconfig"
endif
```
